# Repository SDP-DT04/KiCad-Design

File README.md:

# KiCad-Design
KiCad files for circuit board design

## KiCad design SeniorDesignProject/SeniorDesign.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7: 0.1uF; C_0805
C8, C13, C14: 10uF; CP_Tantalum_Case-T_EIA-3528-12_Hand
C9, C10: 10u; CP_Radial_D5.0mm_P2.00mm
C11: .33uF; CP_Radial_D5.0mm_P2.00mm
C12: .1uF; CP_Radial_D5.0mm_P2.00mm
CPU1: dsPIC33EP256MC506; TQFP-64_10x10mm_Pitch0.5mm
J1: RJ45(LoadCells); RJ45_8
J2: RJ45(Accelerometer); RJ45_8
J3: PICkit3; Pin_Header_Straight_1x06_Pitch2.54mm
J5: ID-12LA Header; Socket_Strip_Straight_1x05_Pitch2.54mm
J6: XBEE Header; XBEE-HEADER
J7: 7-Segment Display; Socket_Strip_Straight_1x05_Pitch2.54mm
P7: Power 1; Pin_Header_Straight_1x02_Pitch3.96mm_Friction_Lock
R1: 80.6; R_0805
R2: 10k; R_0805
R5, R6: 4.7k; R_0805
U1: INA827; MSOP-8_3x3mm_Pitch0.65mm
U2: LM1117-3.3; SOT-223
U3: ICL7660; SOIC-8_3.9x4.9mm_Pitch1.27mm
U4: 7805; TO-92_Inline_Wide

Connections:
3.3V: C3.1, C4.1, C5.2, C6.1, C7.1, C14.1, CPU1.10 (Vdd), CPU1.19 (AVdd), CPU1.26 (Vdd), CPU1.38 (Vdd), CPU1.57 (Vdd), J2.1, J3.2, J6.1, J7.1, R2.1, R5.1, R6.1, U2.2 (VO), U2.4 (VO)
+5V: C2.1, C12.1, C13.1, J1.8, J5.1, J7.2, U1.8 (V+), U2.3 (VI), U3.8, U4.VO; also elsewhere on the board
+9V: C11.1, P7.2, U4.VI; also elsewhere on the board
-5V: C1.2, C10.1, U1.5 (V-), U3.5
A+: J1.5, U1.4 (+)
A-: J1.4, U1.1 (-)
AN13: CPU1.28 (AN13/C3IN2-/~U2CTS~/RE13), U1.7 (Vout)
CP: CPU1.49 (TMS/ASDA1/RP41/RB9), J5.5
LED: CPU1.47 (RC13), J5.3
MCLR: CPU1.7 (~MCLR), J3.1, R2.2
MISO: CPU1.34 (SDI1/RPI25/RA9), J2.8
MOSI: CPU1.33 (CVREF2O/SDO1/RP20/T1CK/RA4), J2.4
unnamed: C8.1, CPU1.56 (Vcap)
unnamed: C9.1, U3.2
unnamed: C9.2, U3.4
unnamed: R1.1, U1.2 (Rg)
unnamed: R1.2, U1.3 (Rg)
PGEC2: CPU1.44 (PGEC2/ASCL2/RP38/RB6), J3.5
PGED2: CPU1.43 (PGED2/ASDA2/RP37/RB5), J3.4
SCK: CPU1.35 (SCK1/RPI51/RC3), J2.6
SCL1: CPU1.37 (SCL1/RPI53/RC5), J7.5, R6.2
SDA1: CPU1.36 (SDA1/RPI52/RC4), J7.4, R5.2
SS: CPU1.15 (PGED3/VREF-/AN2/C2IN1-/~SS1~/RPI32/CTED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), J2.2
UART1RX: CPU1.46 (RP39/INT0/RB7), J5.4
UART1TX: CPU1.50 (RP54/RC6)
UART2RX: CPU1.62 (RPI44/PWM2H/RB12), J6.2
UART2TX: CPU1.61 (RP43/PWM3L/RB11), J6.3

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
Board: 2 copper layers, 69.8 x 63.5 mm, 30 parts (7 on the bottom side), 27 nets.

Other parts of the board:
U9: 7805; TO-92_Inline_Wide

Their connections:
+5V: U9.1; also elsewhere on the board
+9V: U9.3; also elsewhere on the board

## Commit log

2017-01-30 updates 1/30/2017
2017-02-14 Updates to project
2017-02-14 added new files
2017-02-21 Updates to the project
2017-02-22 Updates to board
2017-02-22 Carl
2017-02-23 added some traces
2017-02-27 Added Rfid board to project files
2017-02-28 Updated RFID board with silk screen labels and moved some traces, Bothom copper poor not showing though...
2017-03-01 Added silk screen and gerber files for osh park fabrication
2017-03-03 Updated board layout and design
2017-03-03 Added TL7660 +5V ro -5V converter, Removed 7905 Regulator Removed -9V connection
2017-03-03 Added TC7660 +5V to -5V converter Removed -9V power Removed 7905 -9V to -5V regulator
2017-03-08 Made more changes to board design and layout
2017-03-08 Fixed copper pour
2017-03-10 Routed main board, still need to ad LED indicaters
2017-03-11 Added accelerometer board (V1)
2017-03-15 Changed accelerometer to SPI rather than I2C
2017-03-17 Updates to accelerometer board and main board
2017-03-20 Updates to main board
2017-03-21 Re routed traces added tantalum cap for vcap
2017-03-22 Updates (Final design)
2017-04-04 potato
2017-04-09 Version 2 updates 3.3V regulator with GND, 5V regulator with GND, and added via
2017-04-27 Updates to picture
